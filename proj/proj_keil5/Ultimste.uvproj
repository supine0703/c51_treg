# Keil uVision project Ultimste.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Ultimste +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\src
  group main
    ./: STARTUP.A51
    ../src/: main.c
  group include
    ../include/: __config__.h ds18b20.h lcd1602.h ultimste.h
  group src
    ../src/: __config__.c ds18b20.c lcd1602.c ultimste.c
