# Keil uVision project Ultimate.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Ultimate +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include
  group main
    ./: STARTUP.A51
    ../include/: __config__.h
    ../src/: global.c main.c
  group include
    ../include/: ultimate.h utility.h lcd1602.h ds18b20.h i2c.h at24c02.h
  group src
    ../src/: ultimate.c utility.c lcd1602.c ds18b20.c i2c.c at24c02.c
