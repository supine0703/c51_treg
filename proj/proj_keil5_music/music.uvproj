# Keil uVision project music.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: music +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;D:\install\Keil_v5\C51\INC;..\src
  group Source Group 1
    ./: STARTUP.A51 music.h music.c main.c
    ../include/: at24c02.h i2c.h __config__.h
    ../src/: at24c02.c i2c.c
